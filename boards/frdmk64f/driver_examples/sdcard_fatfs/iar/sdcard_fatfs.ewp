# IAR project sdcard_fatfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12/drivers; ../../../../../middleware/fatfs_0.11a/src; ../../../../../middleware/fatfs_0.11a/src/fsl_sd_disk; ..; ../../../../../devices/MK64F12/utilities; ../../../../../middleware/sdmmc_2.0.0/inc; ../../../../../middleware/sdmmc_2.0.0/src; ../../..; ../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sdcard_fatfs.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: sdcard_fatfs.c sdhc_config.h event.c ffconf.h
  group FATFS_Source
    ../../../../../middleware/fatfs_0.11a/src/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
    ../../../../../middleware/fatfs_0.11a/src/: integer.h ff.c ff.h diskio.c diskio.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc/src
    ../../../../../middleware/sdmmc_2.0.0/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc_2.0.0/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h
