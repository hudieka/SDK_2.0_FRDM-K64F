<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>board</name>
    <file>
      <name>$PROJ_DIR$\..\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\clock_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\clock_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pin_mux.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pin_mux.h</name>
    </file>
  </group>
  <group>
    <name>doc</name>
    <file>
      <name>$PROJ_DIR$\..\readme.txt</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_pit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_smc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_smc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\drivers\fsl_uart.h</name>
    </file>
  </group>
  <group>
    <name>source</name>
    <file>
      <name>$PROJ_DIR$\..\gpio_uart_demo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\gpio_uart_driver.c</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\iar\startup_MK64F12.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\system_MK64F12.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\system_MK64F12.h</name>
    </file>
  </group>
  <group>
    <name>utilities</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\utilities\fsl_debug_console.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\devices\MK64F12\utilities\fsl_debug_console.h</name>
    </file>
  </group>
</project>


