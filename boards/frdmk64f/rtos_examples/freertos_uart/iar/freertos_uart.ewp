# IAR project freertos_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12/drivers; ..; ../../../../../devices/MK64F12/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_uart.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group freertos
    ../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group drivers/freertos
    ../../../../../devices/MK64F12/drivers/: fsl_uart_freertos.h fsl_uart_freertos.c
  group source
    ../: FreeRTOSConfig.h freertos_uart.c
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group board/board
    ../: pin_mux.c pin_mux.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
