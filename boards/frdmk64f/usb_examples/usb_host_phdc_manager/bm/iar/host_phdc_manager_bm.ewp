# IAR project host_phdc_manager_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK64FN1M0VMD12; USB_STACK_BM; PRINTF_FLOAT_ENABLE; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MK64F12/utilities; ../../../../../../middleware/usb_1.0.0; ../../../../../../middleware/usb_1.0.0/osa; ../../../../../../middleware/usb_1.0.0/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.0.0/host; ../../../../../../devices/MK64F12/drivers; ../../../../../../middleware/usb_1.0.0/host/class; ../../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_phdc_manager_bm.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK64FN1M0VMD12; USB_STACK_BM; PRINTF_FLOAT_ENABLE; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group usb/host
    ../../../../../../middleware/usb_1.0.0/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.0.0/host/class/: usb_host_phdc.c usb_host_phdc.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: app.c host_phdc_manager.c host_phdc_manager.h ieee11073_nomenclature.h ieee11073_nomenclature.c ieee11073_types.h usb_host_config.h
  group utilities
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
